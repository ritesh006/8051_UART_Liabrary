# Keil uVision project UART_Library.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: UART_Library +hex
  c flags: Optimize=8 SizeSpeed=1
  group Application
    ./: main.c
  group Driver
    ./: UART_driver.c delay.c lcd.c
